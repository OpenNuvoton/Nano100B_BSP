# IAR project fmc_ld_boot.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100BN series Nuvoton Nano100BN series (Nano100BN,Nano110BN,Nano120BN,Nano130BN)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include; $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fmc_ld_boot.bin
  ILINK.IlinkOutputFile: fmc_ld_boot.out
  ILINK.IlinkIcfFile: fmc_ld_boot.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/IAR/: startup_Nano100Series.s
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group Source Files
    ../: ld_boot.c
