# Keil uVision project SYS_PowerDown_MinCurrent.uvprojx, settings and files
target SYS_PowerDown_MinCurrent (6150000::V6.15::ARMCLANG)
  device: NANO110RE3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SYS_PowerDown_MinCurrent
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_nano100series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: gpio.c clk.c sys.c retarget.c uart.c
