# Keil uVision project Smpl_Basic01_Timer.uvprojx, settings and files
target Smpl_Basic01_Timer (6150000::V6.15::ARMCLANG)
  device: NANO110RE3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Smpl_Basic01_Timer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG_PORT = UART1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\NuEdu\inc;..\..\..\..\Library\Device\Nuvoton\Nano100Series\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group Libraries
    ../../../../Library/StdDriver/src/: clk.c sys.c gpio.c timer.c
  group Common
    ../../../../Library/StdDriver/src/: retarget.c
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group User
    ../: main.c
  group NuEdu
    ../../../../Library/NuEdu/src/: NuEdu-Basic01_System.c NuEdu-Basic01_7_Segment.c
