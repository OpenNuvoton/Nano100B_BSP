# Keil uVision project SimpleHOGP.uvproj, settings and files
target SimpleHOGP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NANO130KE3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1EBFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: SimpleHOGP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=161
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\BLE_AB1602\Library\include
  asm define: Heap_Size=0x3000 Stack_Size=0x400
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1ec00
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\porting\NANO100\Nano100Series.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group User
    ../: main.c SimpleHOGP_Gatt.c SimpleHOGP_Gap.c SimpleHOGP_Gap_Adv.c SimpleHOGP.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c fmc.c gpio.c pdma.c spi.c sys.c timer.c uart.c
  group BleHal
    ../../porting/NANO100/: bt_porting_flash.c bt_porting_misc.c bt_porting_mmi_timer.c bt_porting_spi.c
  group BleStack
    ../../../../ThirdParty/BLE_AB1602/Library/source/blestack/: 1602_patching.c BtCoreM0.lib
  group GattServices
    ../../../../ThirdParty/BLE_AB1602/Library/source/services/: service_human_interface_device.c service_battery.c service_device_information.c service_generic_access.c service_generic_attribute.c
